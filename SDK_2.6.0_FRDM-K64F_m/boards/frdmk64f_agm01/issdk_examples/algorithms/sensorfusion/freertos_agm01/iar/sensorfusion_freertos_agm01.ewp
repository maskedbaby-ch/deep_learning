# IAR project sensorfusion_freertos_agm01.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 NXP MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK64FN1M0VLL12; FRDM_K64F; FREEDOM; PRINTF_ADVANCED_ENABLE; FSL_RTOS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/IAR/ARM_CM4F; ../../../../..; ..; ../../../../../../../CMSIS/Include; ../../../../../../../devices; ../../../../../../../platform/drivers; ../../../../../../frdmk64f; ../../../../../../../rtos/amazon-freertos/lib/include; ../../../../../../../rtos/amazon-freertos/lib/include/private; ../../../../../../../devices/MK64F12/drivers; ../../../../../../../devices/MK64F12/drivers; ../../../../../../../devices/MK64F12/drivers; ../../../../../../../devices/MK64F12/cmsis_drivers; ../../../../../../../devices/MK64F12/drivers; ../../../../../../../devices/MK64F12/drivers; ../../../../../../../devices/MK64F12/drivers; ../../../../../../../devices/MK64F12/drivers; ../../../../../../../devices/MK64F12/cmsis_drivers; ../../../../../../../devices/MK64F12/drivers; ../../../../../../../devices/MK64F12/drivers; ../../../../../../../devices/MK64F12/drivers; ../../../../../../../devices/MK64F12/drivers; ../../../../../../../devices/MK64F12/cmsis_drivers; ../../../../../../../devices/MK64F12/drivers; ../../../../../../../devices/MK64F12/drivers; ../../../../../../../devices/MK64F12/drivers; ../../../../../../../middleware/issdk/drivers/systick; ../../../../../../../middleware/issdk/drivers/gpio; ../../../../../../../middleware/issdk/drivers/gpio/kinetis; ../../../../../../../middleware/issdk/algorithms/sensorfusion/sources; ../../../../../../../middleware/issdk/sensors; ../../../../../../../middleware/issdk/sensors; ../../../../../../../middleware/issdk/sensors; ../../../../../../../middleware/issdk/sensors; ../../../../../../../devices/MK64F12/drivers; ../../../../../../../devices/MK64F12/utilities/str; ../../../../../../../devices/MK64F12/utilities/debug_console; ../../../../../../../components/uart; ../../../../../../../components/serial_manager; ../../../../../../../components/serial_manager; ../../../../../../../components/lists; ../../../../../../../devices/MK64F12; ../../../../../../../devices/MK64F12/drivers; ../../../../../../../CMSIS/Driver/Include; ../../../../../../../CMSIS/Driver/Include; ../../../../../../../devices/MK64F12/template; ../../../../../../../CMSIS/Driver/Include; ../../../../../../../CMSIS/Driver/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: K64F-AGM01-SENSORFUSION-FREERTOS.bin
  ILINK.IlinkOutputFile: sensorfusion_freertos_agm01.out
  ILINK.IlinkIcfFile: MK64FN1M0xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK64FN1M0VLL12; FRDM_K64F; FREEDOM; PRINTF_ADVANCED_ENABLE; FSL_RTOS_FREE_RTOS
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group board
    ../../../../../: frdm_k64f.c frdm_k64f.h frdm_stbc_agm01_shield.h issdk_hal.h RTE_Device.h
    ../: pin_mux.c pin_mux.h clock_config.c clock_config.h board.c board.h
    ../../../../../../../devices/MK64F12/template/: RTE_Device.h
  group source
    ../: build.h FreeRTOSConfig.h main_agm01_freertos_two_tasks.c
  group doc
    ../: readme.txt readme.txt
  group drivers
    ../../../../../../../devices/MK64F12/drivers/: fsl_port.h fsl_uart.c fsl_uart.h fsl_uart_edma.c fsl_uart_edma.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_i2c_edma.c fsl_i2c_edma.h fsl_dmamux.c fsl_dmamux.h fsl_edma.c fsl_edma.h fsl_dspi.c fsl_dspi.h fsl_dspi_edma.c fsl_dspi_edma.h fsl_flash.h fsl_ftfx_adapter.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_features.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_ftfx_utilities.h fsl_smc.c fsl_smc.h fsl_pit.c fsl_pit.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h
    ../../../../../../../devices/MK64F12/cmsis_drivers/: fsl_uart_cmsis.c fsl_uart_cmsis.h fsl_i2c_cmsis.c fsl_i2c_cmsis.h fsl_dspi_cmsis.c fsl_dspi_cmsis.h
  group drivers/freertos
    ../../../../../../../devices/MK64F12/drivers/: fsl_i2c_freertos.c fsl_i2c_freertos.h
  group utilities
    ../../../../../../../middleware/issdk/drivers/systick/: systick_utils.c systick_utils.h
    ../../../../../../../devices/MK64F12/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../../devices/MK64F12/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../../devices/MK64F12/utilities/: fsl_assert.c
  group gpio_driver
    ../../../../../../../middleware/issdk/drivers/gpio/: Driver_GPIO.h
    ../../../../../../../middleware/issdk/drivers/gpio/kinetis/: gpio_driver.c gpio_driver.h gpio_driver_irq.c
  group sensor_fusion
    ../../../../../../../middleware/issdk/algorithms/sensorfusion/sources/: DecodeCommandBytes.c approximations.c approximations.h calibration_storage.c calibration_storage.h control.c control.h debug.c debug.h driver_FXAS21002.c driver_FXOS8700.c driver_KSDK_NVM.c driver_KSDK_NVM.h driver_MPL3115.c driver_pit.c driver_pit.h driver_systick.c drivers.h fusion.c fusion.h hal_frdm_fxs_mult2_b.c magnetic.c magnetic.h matrix.c matrix.h orientation.c orientation.h output_stream.c precisionAccelerometer.c precisionAccelerometer.h sensor_fusion.c sensor_fusion.h status.c status.h
  group interfaces
    ../../../../../../../middleware/issdk/sensors/: register_io_i2c.c register_io_i2c.h register_io_spi.c register_io_spi.h sensor_drv.h sensor_io_i2c.c sensor_io_i2c.h sensor_io_spi.c sensor_io_spi.h
  group sensors
    ../../../../../../../middleware/issdk/sensors/: fxas21002.h fxas21002_drv.c fxas21002_drv.h fxos8700.h fxos8700_drv.c fxos8700_drv.h mpl3115.h mpl3115_drv.c mpl3115_drv.h
  group amazon-freertos/freertos
    ../../../../../../../rtos/amazon-freertos/lib/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group amazon-freertos/freertos/portable
    ../../../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
    ../../../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/: readme.txt
    ../../../../../../../rtos/amazon-freertos/lib/FreeRTOS/portable/MemMang/: heap_1.c
  group amazon-freertos/include
    ../../../../../../../rtos/amazon-freertos/lib/include/: FreeRTOS.h event_groups.h freertos_tasks_c_additions.h message_buffer.h queue.h semphr.h stream_buffer.h task.h timers.h
    ../../../../../../../rtos/amazon-freertos/lib/include/private/: deprecated_definitions.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h stack_macros.h threading_alt.h
  group component/uart
    ../../../../../../../components/uart/: uart.h uart_adapter.c
  group component/serial_manager
    ../../../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component/lists
    ../../../../../../../components/lists/: generic_list.c generic_list.h
  group device
    ../../../../../../../devices/MK64F12/: MK64F12.h MK64F12_features.h fsl_device_registers.h system_MK64F12.c system_MK64F12.h
  group startup
    ../../../../../../../devices/MK64F12/iar/: startup_MK64F12.s
  group CMSIS
    ../../../../../../../CMSIS/Include/: core_cm4.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h mpu_armv7.h mpu_armv8.h
  group CMSIS_driver
    ../../../../../../../CMSIS/Driver/Include/: Driver_USART.h Driver_Common.h Driver_I2C.h Driver_SPI.h
