# IAR project bubble.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 NXP MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK64FN1M0VLL12; PRINTF_ADVANCED_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; FRDM_K64F; FREEDOM; PLATFORM_ARM
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../platform/components/fxos8700cq; ..; ../../..; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../devices/MK64F12/drivers; ../../../../../devices/MK64F12/drivers; ../../../../../components/fxos8700cq; ../../../../../devices/MK64F12/drivers; ../../../../../devices/MK64F12/drivers; ../../../../../devices/MK64F12/drivers; ../../../../../devices/MK64F12/drivers; ../../../../../devices/MK64F12/drivers; ../../../../../devices/MK64F12/utilities/str; ../../../../../devices/MK64F12/utilities/debug_console; ../../../../../devices/MK64F12/drivers; ../../../../../devices/MK64F12; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/serial_manager; ../../../../../components/lists; ../../../../../devices/MK64F12/drivers; inc; inc\layers; port; src\backends; src\core; src\layers; ..\..\..\..\..\middleware\sdmmc\port; ..\..\..\..\..\middleware\fatfs\source\fsl_sd_disk; ..\..\..\..\..\middleware\sdmmc\inc; ..\..\..\..\..\middleware\sdmmc\src; ..\..\..\..\..\middleware\fatfs\source
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: bubble.bin
  ILINK.IlinkOutputFile: bubble.out
  ILINK.IlinkIcfFile: MK64FN1M0xxx12_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; CPU_MK64FN1M0VLL12; PRINTF_ADVANCED_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; FRDM_K64F; FREEDOM
  ICCARM.CCIncludePath2: ../../../../../platform/components/fxos8700cq; ..; ../../..; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../devices/MK64F12/drivers; ../../../../../devices/MK64F12/drivers; ../../../../../components/fxos8700cq; ../../../../../devices/MK64F12/drivers; ../../../../../devices/MK64F12/drivers; ../../../../../devices/MK64F12/drivers; ../../../../../devices/MK64F12/drivers; ../../../../../devices/MK64F12/drivers; ../../../../../devices/MK64F12/utilities/str; ../../../../../devices/MK64F12/utilities/debug_console; ../../../../../devices/MK64F12/drivers; ../../../../../devices/MK64F12; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/serial_manager; ../../../../../components/lists; ../../../../../devices/MK64F12/drivers
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group audio_par
    ../../../../../../../../ML/nnom-master/examples/rnn-denoise/: denoise_weights.h equalizer_coeff.h mfcc.c mfcc.h wav.h weights.h
  group board
    ../: board.c board.h clock_config.c clock_config.h image.h pin_mux.c pin_mux.h weights.h
  group CMSIS
    ../../../../../CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm4.h mpu_armv7.h mpu_armv8.h
  group component/lists
    ../../../../../components/lists/: generic_list.c generic_list.h
  group component/serial_manager
    ../../../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
  group component/uart
    ../../../../../components/uart/: uart.h uart_adapter.c
  group device
    ../../../../../devices/MK64F12/: fsl_device_registers.h MK64F12.h MK64F12_features.h system_MK64F12.c system_MK64F12.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MK64F12/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_flash.h fsl_ftfx_adapter.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_features.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_ftfx_utilities.h fsl_ftm.c fsl_ftm.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_port.h fsl_sdhc.c fsl_smc.c fsl_smc.h fsl_uart.c fsl_uart.h
  group fatfs/fatfs_include
    ../../../../../middleware/fatfs/source/: diskio.h ff.h integer.h
    ../../../../../middleware/fatfs/source/fsl_sd_disk/: fsl_sd_disk.h
  group fatfs/fatfs_source
    ../../../../../middleware/fatfs/source/: diskio.c ff.c ffsystem.c ffunicode.c
    ../../../../../middleware/fatfs/source/fsl_sd_disk/: fsl_sd_disk.c
  group inc
    inc/: nnom.h nnom_layers.h nnom_local.h nnom_tensor.h nnom_utils.h
  group inc/layers
    inc/layers/: nnom_activation.h nnom_avgpool.h nnom_baselayer.h nnom_concat.h nnom_conv2d.h nnom_conv2d_trans.h nnom_cropping.h nnom_dense.h nnom_dw_conv2d.h nnom_flatten.h nnom_global_pool.h nnom_gru_cell.h nnom_input.h nnom_lambda.h nnom_lstm_cell.h nnom_matrix.h nnom_maxpool.h nnom_output.h nnom_rnn.h nnom_simple_cell.h nnom_softmax.h nnom_sumpool.h nnom_upsample.h nnom_zero_padding.h
  group port
    port/: nnom_port.h
  group sdmmc/inc
    ../../../../../middleware/sdmmc/inc/: fsl_sd.h fsl_sdmmc_common.h fsl_sdmmc_host.h fsl_sdmmc_spec.h
  group sdmmc/port
    ../../../../../middleware/sdmmc/port/sdhc/interrupt/: fsl_sdmmc_event.c fsl_sdmmc_host.c
    ../../../../../middleware/sdmmc/port/: fsl_sdmmc_event.h
  group sdmmc/src
    ../../../../../middleware/sdmmc/src/: fsl_sd.c fsl_sdmmc_common.c
  group source
    ../: bubble.c ffconf.h
  group src/backends
    src/backends/: nnom_local.c nnom_local_q15.c
  group src/core
    src/core/: nnom.c nnom_layers.c nnom_tensor.c nnom_utils.c
  group src/layers
    src/layers/: nnom_activation.c nnom_avgpool.c nnom_baselayer.c nnom_concat.c nnom_conv2d.c nnom_conv2d_trans.c nnom_cropping.c nnom_dense.c nnom_dw_conv2d.c nnom_flatten.c nnom_global_pool.c nnom_gru_cell.c nnom_input.c nnom_lambda.c nnom_lstm_cell.c nnom_matrix.c nnom_maxpool.c nnom_output.c nnom_rnn.c nnom_simple_cell.c nnom_softmax.c nnom_sumpool.c nnom_upsample.c nnom_zero_padding.c
  group startup
    ../../../../../devices/MK64F12/iar/: startup_MK64F12.s
  group utilities
    ../../../../../devices/MK64F12/utilities/: fsl_assert.c
    ../../../../../devices/MK64F12/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MK64F12/utilities/str/: fsl_str.c fsl_str.h
